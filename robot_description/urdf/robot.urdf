Commit message: seventh checkpoint

File: robot_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot myRobot, 7 links, 6 joints
Joints:
- joint left_gripper_joint: axis 0 1 0 -> 0 -1 0
